# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __RTTHREAD__, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: rt-thread\components\net\at\include;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\dev_model\client;rt-thread\components\net\at\at_socket;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\rw007-v2.1.0\inc;rt-thread\components\net\netdev\include;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\drivers\include;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\dev_model;rt-thread\components\net\sal\include\dfs_net;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\mqtt;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\infra;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;packages\aht10-latest\inc;libraries\HAL_Drivers\drivers\config;rt-thread\components\net\sal\impl;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\dev_sign;rt-thread\components\drivers\include;rt-thread\include;packages\rw007-v2.1.0;rt-thread\components\net\sal\include\socket;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board\CubeMX_Config\Inc;packages\cJSON-v1.7.17;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\CMSIS\Include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\HAL_Drivers\drivers;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\compilers\common\extension;packages\ali-iotkit-v3.0.2\iotkit-embedded\wrappers;rt-thread\components\drivers\spi;rt-thread\components\drivers\wlan;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\sal\include;packages\ap3216c-latest;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip\port;applications;rt-thread\components\drivers\include;board;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\audio;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\ipc;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\mqtt\impl;rt-thread\components\drivers\include;board\ports;.;packages\ali-iotkit-v3.0.2\iotkit-embedded\src\dev_model\server;libraries\HAL_Drivers;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group aht10
    packages/aht10-latest/src/: aht10.c
  group ali-iotkit
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/infra/: infra_compat.c infra_log.c infra_string.c infra_timer.c infra_prt_nwk_payload.c infra_net.c infra_sha256.c infra_cjson.c infra_report.c infra_defs.c
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/mqtt/impl/: MQTTPacket.c MQTTUnsubscribeClient.c MQTTSerializePublish.c iotx_mqtt_client.c MQTTSubscribeClient.c MQTTConnectClient.c MQTTDeserializePublish.c
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/dev_model/: dm_api.c iotx_cm_mqtt.c dm_opt.c dm_manager.c dm_ota.c dm_msg_process.c dm_message_cache.c dm_utils.c iotx_cm.c dm_log_report.c impl_linkkit.c dm_message.c dm_ipc.c dm_fota.c dm_cota.c
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-v3.0.2/ports/rtthread/: HAL_OS_rtthread.c HAL_UDP_rtthread.c HAL_TCP_rtthread.c
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/dev_model/client/: dm_client.c dm_client_adapter.c
    packages/ali-iotkit-v3.0.2/ports/: wrapper.c
    packages/ali-iotkit-v3.0.2/iotkit-embedded/src/mqtt/: mqtt_api.c
  group ap3216c
    packages/ap3216c-latest/: ap3216c.c
  group Applications
    applications/: mqtt_clinet.c ap3216_read.c wifi.c aht21_read.c main.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_cli.c at_client.c at_utils.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_soft_i2c.c drv_soft_spi.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: msh_file.c msh.c msh_parse.c cmd.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cec.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_lptim.c stm32f4xx_hal_sai.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_qspi.c stm32f4xx_hal.c stm32f4xx_hal_cryp.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
    packages/rw007-v2.1.0/example/: rw007_stm32_port.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
